# IAR project csi_rgb565.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6B NXP MIMXRT1062xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_EXTERNAL_FLASH=1; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.IExtraOptions: --preinclude ../mcuxsdk_version.h --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../xip; ../../../../../../devices/MIMXRT1062/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1062; ../../../../../../devices/MIMXRT1062/periph; ../../../../../../devices/MIMXRT1062/xip; ../../../../../../devices/MIMXRT1062/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1062/utilities/str; ../../../../../../components/uart; ../../../../../../components/video; ../../../../../../components/video/display/dc; ../../../../../../components/video/display; ../../../../../../components/video/i2c; ../../../../../../components/video/display/dc/elcdif; ../../../../../../components/video/camera; ../../../../../../components/video/camera/device; ../../../../../../components/video/camera/device/sccb; ../../../../../../components/video/camera/device/ov7725; ../../../../../../components/video/camera/device/ov5640; ../../../../../../components/video/camera/device/mt9m114; ../../../../../../components/video/camera/receiver; ../../../../../../components/video/camera/receiver/csi
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES
  AARM.AUserIncludes: ..; ../../../../xip; ../../../../../../devices/MIMXRT1062/drivers; ../../../../../../CMSIS/Core/Include; ../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../devices/MIMXRT1062; ../../../../../../devices/MIMXRT1062/periph; ../../../../../../devices/MIMXRT1062/xip; ../../../../../../devices/MIMXRT1062/utilities/debug_console_lite; ../../../../../../devices/MIMXRT1062/utilities/str; ../../../../../../components/uart; ../../../../../../components/video; ../../../../../../components/video/display/dc; ../../../../../../components/video/display; ../../../../../../components/video/i2c; ../../../../../../components/video/display/dc/elcdif; ../../../../../../components/video/camera; ../../../../../../components/video/camera/device; ../../../../../../components/video/camera/device/sccb; ../../../../../../components/video/camera/device/ov7725; ../../../../../../components/video/camera/device/mt9m114; ../../../../../../components/video/camera/receiver; ../../../../../../components/video/camera/receiver/csi
  AARM.PreInclude: ../mcux_config.h
  OBJCOPY.OOCOutputFile: csi_rgb565.bin
  ILINK.IlinkOutputFile: csi_rgb565.out
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; XIP_EXTERNAL_FLASH=1; USE_SDRAM=1; SKIP_SYSCLK_INIT=1; DATA_SECTION_IS_CACHEABLE=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMXRT1062DVL6B; MIMXRT1062_SERIES; SDK_I2C_BASED_COMPONENT_USED=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group board
    ../: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_iccarm_m.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_COMMON.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group device/periph
    ../../../../../../devices/MIMXRT1062/periph/: PERI_ADC.h PERI_ADC_ETC.h PERI_AIPSTZ.h PERI_AOI.h PERI_BEE.h PERI_CAN.h PERI_CCM.h PERI_CCM_ANALOG.h PERI_CM7_MCM.h PERI_CMP.h PERI_CSI.h PERI_CSU.h PERI_DCDC.h PERI_DCP.h PERI_DMA.h PERI_DMAMUX.h PERI_ENC.h PERI_ENET.h PERI_EWM.h PERI_FLEXIO.h PERI_FLEXRAM.h PERI_FLEXSPI.h PERI_GPC.h PERI_GPIO.h PERI_GPT.h PERI_I2S.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IOMUXC_SNVS.h PERI_IOMUXC_SNVS_GPR.h PERI_KPP.h PERI_LCDIF.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_OCOTP.h PERI_PGC.h PERI_PIT.h PERI_PMU.h PERI_PWM.h PERI_PXP.h PERI_ROMC.h PERI_RTWDOG.h PERI_SEMC.h PERI_SNVS.h PERI_SPDIF.h PERI_SRC.h PERI_TEMPMON.h PERI_TMR.h PERI_TRNG.h PERI_TSC.h PERI_USB.h PERI_USB_ANALOG.h PERI_USBNC.h PERI_USBPHY.h PERI_USDHC.h PERI_WDOG.h PERI_XBARA.h PERI_XBARB.h PERI_XTALOSC24M.h
  group doc
    ../: example_board_readme.md examples_shared_readme.md readme.md
  group drivers
    ../../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_elcdif.c fsl_elcdif.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_pmu.c fsl_pmu.h fsl_src.c fsl_src.h
  group source
    ../: camera_support.c camera_support.h csi_rgb565.c display_support.c display_support.h mcux_config.h mcuxsdk_version.h
  group startup/iar
    ../../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group utilities
    ../../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_assert.c fsl_assert.h
  group utilities/debug_console_lite
    ../../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities/str
    ../../../../../../devices/MIMXRT1062/utilities/str/: fsl_str.c fsl_str.h
  group video
    ../../../../../../components/video/camera/: fsl_camera.h
    ../../../../../../components/video/camera/device/: fsl_camera_device.h
    ../../../../../../components/video/camera/receiver/: fsl_camera_receiver.h
    ../../../../../../components/video/camera/receiver/csi/: fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/camera/device/mt9m114/: fsl_mt9m114.c fsl_mt9m114.h
    ../../../../../../components/video/camera/device/ov5640/: fsl_ov5640.c fsl_ov5640.h
    ../../../../../../components/video/camera/device/ov7725/: fsl_ov7725.c fsl_ov7725.h
    ../../../../../../components/video/camera/device/sccb/: fsl_sccb.c fsl_sccb.h
    ../../../../../../components/video/: fsl_video_common.c fsl_video_common.h
    ../../../../../../components/video/i2c/: fsl_video_i2c.c fsl_video_i2c.h
  group xip
    ../../../../: dcd.c dcd.h
    ../../../../xip/: evkbmimxrt1060_flexspi_nor_config.c evkbmimxrt1060_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
